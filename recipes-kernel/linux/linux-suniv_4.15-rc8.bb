require linux-suniv.inc
SRC_URI += "file://0001-add-support-for-usb-gadget.patch"